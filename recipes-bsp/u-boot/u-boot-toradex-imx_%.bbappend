require u-boot-toradex-tezi.inc

