LDFLAGS:prepend = "-static "
EXTRA_OEMAKE = "'PKG_CONFIG=pkg-config --static'"
