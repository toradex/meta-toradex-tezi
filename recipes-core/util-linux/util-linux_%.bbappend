PACKAGES =+ "util-linux-blkdiscard"

FILES_util-linux-blkdiscard = "${sbindir}/blkdiscard"
