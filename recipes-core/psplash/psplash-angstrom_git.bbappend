# ${BPN} errors to psplash-angstrom instead of psplash, fetch fails.
# hardcode the repo name
BPN_colibri-t20 = "psplash"

