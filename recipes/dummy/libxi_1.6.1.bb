LICENSE = "prop"
#dummy to live with a bbappend in for witch the bb file no longer exists
COMPATIBLE_MACHINE = "none"