RDEPENDS_${PN}_remove = " \
        libqt${QTLIBPREFIX}3support4-dev \
        libqt${QTLIBPREFIX}webkit4-dev \
        "

