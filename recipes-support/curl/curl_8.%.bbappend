FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-tool_operate-resume-at-last-byte-when-retrying.patch \
"
