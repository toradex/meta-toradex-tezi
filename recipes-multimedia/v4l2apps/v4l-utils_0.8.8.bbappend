FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

PRINC = "1"

SRC_URI += "file://initalizer-not-const.patch"

