PACKAGECONFIG:remove = "accessibility udev evdev tools libinput gif examples"
PACKAGECONFIG:append = " optimize-size"
