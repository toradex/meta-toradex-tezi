DEPENDS:remove = "qtdeclarative"
