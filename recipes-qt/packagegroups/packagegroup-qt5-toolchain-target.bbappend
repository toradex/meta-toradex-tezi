RDEPENDS_${PN}_remove = " \
    qtcharts-dev \
    qtcharts-mkspecs \
    qtmultimedia-dev \
    qtmultimedia-mkspecs \
    qtmultimedia-plugins \
"
