DEPENDS += "gobject-introspection-native"

