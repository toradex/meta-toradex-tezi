LIC_FILES_CHKSUM = "file://mmc.c;beginline=1;endline=20;md5=fae32792e20f4d27ade1c5a762d16b7d"

# Contains support for boot bus configuration
SRCREV = "a3d3331e6854a4607133bed152988d51250107ca"
