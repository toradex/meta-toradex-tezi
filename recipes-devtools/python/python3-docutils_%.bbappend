FILESEXTRAPATHS_prepend := "${THISDIR}/python3-docutils/:"

SRC_URI_append = " \
file://rst2man_using_python3.patch \
"
 
