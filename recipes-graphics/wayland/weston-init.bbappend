FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

REQUIRED_DISTRO_FEATURES:remove = "opengl"