RPROVIDES_${PN}-locale_remove = "libx11-locale"
