QTNAME = "qte"
QT_DIR_NAME = "qtopia"

require recipes-qt/meta/meta-toolchain-qt.inc

TOOLCHAIN_TARGET_TASK += " packagegroup-tezi-toolchain-target"

